# Keil uVision project Template.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD
  c misc: -D__weak="__attribute__((weak))" -D__packed="__attribute__((__packed__))" -D__NOINLINE="__attribute__ ( (noinline) )"--locale=english
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE;..\SYSTEM\bsp;..\HARDWARE\usart1;..\HARDWARE\usart2;..\HARDWARE\usart3;..\HARDWARE\uart4;..\HARDWARE\uart5;..\HARDWARE\timer1;..\HARDWARE\timer8;..\HARDWARE\timerx;..\CORE\motor;..\CORE\pid;..\CORE\encoder;..\CORE\servo;..\CORE\gyroscope;..\SYSTEM\priority;..\CORE\gray;..\CORE\map;..\CORE\led;..\CORE\podf;..\CORE\button;..\CORE\event;..\CORE\infrared;..\HARDWARE\iic;..\CORE\pca9685
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
  group USER
    ./: main.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/bsp/: bsp.c
    ../CORE/led/: led.c
    ../SYSTEM/priority/: priority.h
    ../SYSTEM/: trash
  group HARDWARE
    ../HARDWARE/usart1/: usart1.c
    ../HARDWARE/usart2/: usart2.c
    ../HARDWARE/usart3/: usart3.c
    ../HARDWARE/uart4/: uart4.c
    ../HARDWARE/uart5/: uart5.c
    ../HARDWARE/timer1/: timer1.c
    ../HARDWARE/timer8/: timer8.c
    ../HARDWARE/timerx/: timerx.c
    ../HARDWARE/iic/: iic.c
  group CORE
    ../CORE/pid/: pid.c
    ../CORE/motor/: motor.c
    ../CORE/encoder/: encoder.c
    ../CORE/servo/: servo.c
    ../CORE/gyroscope/: gyroscope.c
    ../CORE/gray/: gray.c
    ../CORE/map/: map.c
    ../CORE/podf/: podf.c
    ../CORE/button/: button.c
    ../CORE/event/: event.c
    ../CORE/infrared/: infrared.c
    ../CORE/pca9685/: pca9685.c
  group README
    ../: README
